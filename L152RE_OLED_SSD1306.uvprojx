# Keil uVision project L152RE_OLED_SSD1306.uvprojx, settings and files
target mbed NUCLEO_F031K6 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F031K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: L152RE_OLED_SSD1306
  AfterMake: fromelf --bin -o build\L152RE_OLED_SSD1306_NUCLEO_F031K6.bin build\L152RE_OLED_SSD1306.axf
  c flags: Optim=1
  c define: __CORTEX_M0,  TARGET_FF_ARDUINO,  MBED_BUILD_TIMESTAMP=1454687229.08,  TARGET_CORTEX_M,  TOOLCHAIN_ARM_MICRO,  TARGET_NUCLEO_F031K6,  TARGET_STM32F031K6,  TARGET_STM,  TARGET_STM32F0,  TARGET_M0,  ARM_MATH_CM0,  TOOLCHAIN_ARM,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  SSD1306;  mbed;  mbed/TARGET_NUCLEO_F031K6;  mbed/TARGET_NUCLEO_F031K6/TARGET_STM;  mbed/TARGET_NUCLEO_F031K6/TARGET_STM/TARGET_STM32F0;  mbed/TARGET_NUCLEO_F031K6/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F031K6;  mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx.sct
  link misc: mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_smartcard.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/board.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/cmsis_nvic.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/hal_tick.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/mbed_overrides.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/retarget.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/startup_stm32f031x6.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_adc.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_adc_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_can.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_cec.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_comp.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_cortex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_crc.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_crc_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_dac.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_dac_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_dma.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_flash.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_flash_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_gpio.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_i2c.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_i2c_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_i2s.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_irda.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_iwdg.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_pcd.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_pcd_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_pwr.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_pwr_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_rcc.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_rcc_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_rtc.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_rtc_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_smartcard_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_smbus.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_spi.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_spi_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_tim.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_tim_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_tsc.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_uart.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_uart_ex.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_usart.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/stm32f0xx_hal_wwdg.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/sys.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/system_stm32f0xx.o
            
              mbed/TARGET_NUCLEO_F031K6/TOOLCHAIN_ARM_MICRO/mbed.ar
  group src
    ./: main.cpp
    SSD1306/: ssd1306.cpp
